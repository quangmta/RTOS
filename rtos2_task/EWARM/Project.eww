<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\rtos2_task.ewp</path>
  </project>
  <batchBuild />
</workspace>
